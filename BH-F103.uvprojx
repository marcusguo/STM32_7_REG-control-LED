# Keil uVision project BH-F103.uvprojx, settings and files
target Template-REG (5060750::V5.06 update 6 (build 750)::.\ARM_Compiler_5.06u6)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template-REG +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\Objects\Template-REG.sct
  group Source Group 1
    ./: startup_stm32f10x_hd.s main.c
